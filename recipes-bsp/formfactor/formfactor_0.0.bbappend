FILESEXTRAPATHS_prepend_vcoreiii := "${THISDIR}/${PN}:"
